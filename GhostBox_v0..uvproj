# Keil uVision project GhostBox_v0..uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: GhostBox_v0.1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: i2c.c i2c.h main.c main.h RDA5807M.c RDA5807M.h USART.c USART.h utils.c utils.h
